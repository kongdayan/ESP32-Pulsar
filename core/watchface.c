#include "watchface.h"

#include <stdio.h>
#include <string.h>

/* 每个字符 7 行、每行低 5 位表示 5 个像素点（高位在左） */
static const uint8_t k_glyph_blank[WF_GLYPH_ROWS]  = { 0, 0, 0, 0, 0, 0, 0 };
static const uint8_t k_glyph_percent[WF_GLYPH_ROWS] = { 0x19, 0x1A, 0x04, 0x08, 0x13, 0x13, 0x00 };
static const uint8_t k_glyph_colon[WF_GLYPH_ROWS]   = { 0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00 };
static const uint8_t k_glyph_arrow[WF_GLYPH_ROWS]   = { 0x10, 0x08, 0x04, 0x02, 0x04, 0x08, 0x10 };
static const uint8_t k_glyph_underscore[WF_GLYPH_ROWS] = { 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F };

static const uint8_t k_glyph_alnum[WF_GLYPH_TABLE_SIZE][WF_GLYPH_ROWS] = {
    { 0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E }, /* 0 */
    { 0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E }, /* 1 */
    { 0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F }, /* 2 */
    { 0x1E, 0x01, 0x01, 0x0E, 0x01, 0x01, 0x1E }, /* 3 */
    { 0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02 }, /* 4 */
    { 0x1F, 0x10, 0x1E, 0x01, 0x01, 0x11, 0x0E }, /* 5 */
    { 0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E }, /* 6 */
    { 0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08 }, /* 7 */
    { 0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E }, /* 8 */
    { 0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C }, /* 9 */
    { 0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11 }, /* A */
    { 0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E }, /* B */
    { 0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E }, /* C */
    { 0x1E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E }, /* D */
    { 0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F }, /* E */
    { 0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10 }, /* F */
    { 0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F }, /* G */
    { 0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11 }, /* H */
    { 0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E }, /* I */
    { 0x07, 0x02, 0x02, 0x02, 0x12, 0x12, 0x0C }, /* J */
    { 0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11 }, /* K */
    { 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F }, /* L */
    { 0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11 }, /* M */
    { 0x11, 0x19, 0x15, 0x13, 0x11, 0x11, 0x11 }, /* N */
    { 0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E }, /* O */
    { 0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10 }, /* P */
    { 0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D }, /* Q */
    { 0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11 }, /* R */
    { 0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E }, /* S */
    { 0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04 }, /* T */
    { 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E }, /* U */
    { 0x11, 0x11, 0x11, 0x11, 0x0A, 0x0A, 0x04 }, /* V */
    { 0x11, 0x11, 0x11, 0x15, 0x15, 0x1B, 0x11 }, /* W */
    { 0x11, 0x0A, 0x04, 0x04, 0x04, 0x0A, 0x11 }, /* X */
    { 0x11, 0x0A, 0x04, 0x04, 0x04, 0x04, 0x04 }, /* Y */
    { 0x1F, 0x02, 0x04, 0x04, 0x08, 0x10, 0x1F }, /* Z */
};

const uint8_t *wf_glyph_for(char c)
{
    if (c == ' ') return k_glyph_blank;
    if (c == '%') return k_glyph_percent;
    if (c == ':') return k_glyph_colon;
    if (c == '>') return k_glyph_arrow;
    if (c == '_') return k_glyph_underscore;
    if (c >= WF_DIGIT_ZERO && c <= '9') return k_glyph_alnum[c - WF_DIGIT_ZERO];
    if (c >= WF_LETTER_A_LOWER && c <= WF_LETTER_Z_LOWER) {
        c = (char)(c - WF_LETTER_A_LOWER + WF_LETTER_A_UPPER);
    }
    if (c >= WF_LETTER_A_UPPER && c <= WF_LETTER_Z_UPPER) {
        return k_glyph_alnum[WF_GLYPH_DIGITS + c - WF_LETTER_A_UPPER];
    }
    return k_glyph_blank;
}

bool wf_glyph_pixel(const uint8_t *glyph, int row, int col)
{
    if (glyph == NULL) return false;
    if (row < 0 || row >= WF_GLYPH_ROWS) return false;
    if (col < 0 || col >= WF_GLYPH_COLS) return false;
    return (glyph[row] & (uint8_t)(1u << (WF_GLYPH_COLS - 1 - col))) != 0u;
}

int wf_glyph_advance(int step)
{
    return WF_GLYPH_ADVANCE * step;
}

int wf_dot_text_width(const char *text, int step)
{
    const size_t len = (text != NULL) ? strlen(text) : 0u;
    if (len == 0u) return 0;
    return (int)len * wf_glyph_advance(step) - step;
}

int wf_right_align_x(int right_x, const char *text, int step)
{
    return right_x - wf_dot_text_width(text, step);
}

int wf_center_align_x(int screen_px, const char *text, int step)
{
    return (screen_px - wf_dot_text_width(text, step)) / 2;
}

int wf_progress_steps(int total_steps, int percent)
{
    return ui_steps_for_percent(total_steps, percent);
}

int wf_battery_cells(int percent)
{
    const int clamped = ui_clampi(percent, WF_BATTERY_MIN_PCT, WF_BATTERY_MAX_PCT);
    return (clamped + WF_BATTERY_ROUND) / WF_BATTERY_DIVISOR;
}

int wf_format_percent(char *out, size_t out_sz, int percent)
{
    if (out == NULL || out_sz == 0u) return 0;
    return snprintf(out, out_sz, "%d%%", percent);
}
